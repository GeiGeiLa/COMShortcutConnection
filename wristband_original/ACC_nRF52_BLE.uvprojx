# Keil uVision project ACC_nRF52_BLE.uvprojx, settings and files
target ACC_nRF52_BLE (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: ACC +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_ENABLE BLE_STACK_SUPPORT_REQD RAYTAC52 FPU_INTERRUPT_MODE ARM_MATH_CM4 NRF52832_XXAA NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 NRF52 NRF_SD_BLE_API_VERSION=4 S132 SOFTDEVICE_PRESENT SWI_DISABLE0 CONFIG_NFCT_PINS_AS_GPIOS
  c include: .\config;..\components;..\components\drivers_nrf\common;..\components\drivers_nrf\delay;..\components\drivers_nrf\hal;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\ppi;..\components\drivers_nrf\saadc;..\components\drivers_nrf\timer;..\components\drivers_nrf\uart;..\components\drivers_nrf\twi_master;..\components\drivers_nrf\spi_master;..\components\libraries\button;..\components\libraries\fifo;..\components\libraries\log;..\components\libraries\log\src;..\components\libraries\timer;..\components\libraries\uart;..\components\libraries\util;..\components\toolchain;.\app;.\module;.\Sensor;..\PM25;..\components\ble\ble_advertising;..\components\ble\ble_services\ble_dfu;..\components\ble\common;..\components\ble\nrf_ble_gatt;..\components\ble\peer_manager;..\components\drivers_nrf\clock;..\components\libraries\bsp;..\components\libraries\crc16;..\components\libraries\experimental_section_vars;..\components\libraries\fds;..\components\libraries\fstorage;..\components\libraries\scheduler;..\components\libraries\strerror;..\components\libraries\block_dev;..\components\libraries\block_dev\sdc;..\components\libraries\sdcard;..\components\softdevice\common\softdevice_handler;..\components\softdevice\s132\headers;..\components\softdevice\s132\headers\nrf52;.\BLE;..\components\boards;..\components\libraries\bsp;.\protothreads;.\protothreads\pt-1.4;..\components\ble\ble_services\ble_nus;..\components\drivers_nrf\twi_master;..\components\libraries\pwr_mgmt;..\components\drivers_nrf\power;..\components\drivers_nrf\rtc;..\components\libraries\mutex;..\components\libraries\atomic;..\components\libraries\experimental_section_vars
  asm define: NRF52832 BOARD_CUSTOM NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET BSP_DEFINES_ONLY NRF52
  asm misc: --cpreproc_opts=-DNRF52832,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_30,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_53,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_62,-DNRF52_PAN_63,-DNRF52_PAN_64,-DCONFIG_GPIO_AS_PINRESET,-DBSP_DEFINES_ONLY,-DNRF52
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\bsp;..\..\..;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x200025f8 size 0xda08
  group Application
    ./config/: sdk_config.h common.c app_config.h
    ./app/: main.c adap.c
  group Module
    ./module/: adc.c raytac52.c uart.c timer.c twix.c data_collect.c flash_access.c rtc.c
  group Sensor
    ./Sensor/: w25qxx.c acc.c si705x.c apds930x.c ssd1306.c
  group Documentation
    ./: license.txt
  group nRF_Drivers
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../components/drivers_nrf/hal/: nrf_saadc.c
    ../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../components/drivers_nrf/pwm/: nrf_drv_pwm.c
    ../components/drivers_nrf/rtc/: nrf_drv_rtc.c
  group nRF_Libraries
    ../components/libraries/button/: app_button.c
    ../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../components/libraries/fifo/: app_fifo.c
    ../components/libraries/timer/: app_timer.c
    ../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../components/libraries/fstorage/: fstorage.c
    ../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../components/libraries/experimental_section_vars/: nrf_section_iter.c
  group BLE
    ./BLE/: ble_uarts.c
  group nRF_BLE
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../components/ble/ble_advertising/: ble_advertising.c
    ../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_SoftDevices
    ../components/softdevice/common/softdevice_handler/: softdevice_handler.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:Startup 8.9.0
